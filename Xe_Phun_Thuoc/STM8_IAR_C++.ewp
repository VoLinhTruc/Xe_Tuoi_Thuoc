# IAR project STM8_IAR_C++.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; STM8S_StdPeriph_Driver\src; Bico_Lib; Library_ArduinoOrigin_Site\ArduinoJson-master\; Library_ArduinoOrigin_Site\ArduinoJson-master\src; Library_ArduinoOrigin_Site\ArduinoJson-master\src\ArduinoJson\; Library_ArduinoOrigin_Site\ArduinoJson-master\src\ArduinoJson\Data; Library_ArduinoOrigin_Site\ArduinoJson-master\src\ArduinoJson\Deserialization; Library_ArduinoOrigin_Site\ArduinoJson-master\src\ArduinoJson\Polyfills; Library_ArduinoOrigin_Site\ArduinoJson-master\src\ArduinoJson\Serialization; Library_ArduinoOrigin_Site\ArduinoJson-master\src\ArduinoJson\StringTraits; Library_ArduinoOrigin_Site\ArduinoJson-master\src\ArduinoJson\TypeTraits; Library_ArduinoOrigin_Site\Arduino-DS1307-master; Bico_Lib1
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: STM8_IAR_C++.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: ArduinoStyle.cpp main.cpp
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
  group Bico_Lib
    Bico_Lib/: Bico_STM8_Analog.cpp Bico_STM8_Eeprom.cpp Bico_STM8_Exti.cpp Bico_STM8_Generic.cpp Bico_STM8_Gpio.cpp Bico_STM8_PWM.cpp Bico_STM8_Serial.cpp Bico_STM8_Servo.cpp Bico_STM8_Spi.cpp Bico_STM8_Wire.cpp
  group Bico_Lib1
    Bico_Lib1/: Algebra_Math.c L293D.cpp Logic_Math.c
  group Library_ArduinoOrigin_Site
    Library_ArduinoOrigin_Site/Arduino-DS1307-master/: DS1307.cpp
